# Keil uVision project STM32F103.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C6 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00002800) IROM(0x08000000,0x00008000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32F103
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x2800
  group HEADER FILES
    ./New folder/: STM32F103C8T6_GPIO_DRIVER.h STM32F103C_SPI_DRIVER.h STM32F103C_USART_DRIVER.h STM32F103C_TIMER_DRIVER.h
  group SOURCE FILES
    ./New folder/: STM32F103C8T6_GPIO_DRIVER.c STM32F103C_USART_DRIVER.c STM32F103C_TIMER_DRIVER.c STM32F103C_SPI_DRIVER.c
  group MAIN FILES
    ./: USART_main_1.c
software components: CMSIS:CORE 5.6.0, Device:Startup 1.0.0, Device:StdPeriph Drivers:Framework 3.6.0, Device:StdPeriph Drivers:RCC 3.6.0, Device:StdPeriph Drivers:USART 3.6.0
